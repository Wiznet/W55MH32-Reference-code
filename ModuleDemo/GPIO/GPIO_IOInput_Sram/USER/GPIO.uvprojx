# Keil uVision project GPIO.uvprojx, settings and files
target GPIO (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: W55MH32L WIZnet
  pack: W55MH32.W55MH32_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GPIO +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=Bin\@L.bin !L
  c flags: v6Lang=1 v6LangP=1
  c define: w55mh32_HD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\USER;..\..\..\..\Libraries\w55mh32Lib\inc;..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\Libraries\CORE;..\..\..\..\Libraries\CMSIS\Lib\ARM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: ..\OBJ\GPIO.sct
  group USER
    ./: main.c system_w55mh32.c w55mh32_it.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
  group CORE
    ../../../../Libraries/CORE/: core_cm3.c startup_w55mh32.s
  group FWLib
    ../../../../Libraries/w55mh32Lib/src/: misc.c w55mh32_rcc.c w55mh32_gpio.c w55mh32_usart.c w55mh32_exti.c
