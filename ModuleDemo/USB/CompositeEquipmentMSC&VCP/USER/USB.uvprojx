# Keil uVision project USB.uvprojx, settings and files
target USB (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: W55MH32L WIZnet
  pack: W55MH32.W55MH32_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: USB +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=Bin\@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,W55MH32_XL
  c include: ..\..\..\..\Libraries\w55mh32Lib\inc;..\SYSTEM\led;..\SYSTEM\delay;..\USER;..\USB\CONFIG;..\USB\W55MH32_USB-FS-Device_Driver\inc;..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\Libraries\CORE;..\..\..\..\Libraries\w55mh32Lib\lib;..\..\..\..\ModuleDemo
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group User
    ./: main.c w55mh32_it.c
    ../SYSTEM/delay/: delay.c
  group Startup
    ./: startup_w55mh32.s
  group StdPeriph_Driver
    ../../../../Libraries/w55mh32Lib/src/: w55mh32_gpio.c w55mh32_rcc.c w55mh32_exti.c w55mh32_tim.c w55mh32_usart.c w55mh32_iwdg.c w55mh32_wwdg.c w55mh32_bkp.c w55mh32_pwr.c w55mh32_adc.c w55mh32_dac.c w55mh32_dma.c w55mh32_rtc.c w55mh32_can.c misc.c w55mh32_flash.c w55mh32_spi.c
  group CMSIS
    ../../../../Libraries/CORE/: core_cm3.c
    ./: system_w55mh32.c
  group USB_CORE
    ../USB/W55MH32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group USB_CONFIG
    ../USB/CONFIG/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c memory.c scsi_data.c usb_bot.c usb_scsi.c mass_mal.c Internal_Flash.c w25qxx.c bsp_sdio_sdcard.c ring_buf.c cdc_usart.c
  group LIB
    ../../../../Libraries/w55mh32Lib/lib/: w55mh32.lib
