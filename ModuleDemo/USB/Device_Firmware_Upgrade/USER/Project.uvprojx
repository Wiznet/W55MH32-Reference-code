# Keil uVision project Project.uvprojx, settings and files
target USB (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: W55MH32L WIZnet
  pack: W55MH32.W55MH32_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DFU +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=Bin\@L.bin !L
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,W55MH32_XL
  c misc: --C99
  c include: ..\USER;..\USB\CONFIG;..\USB\W55MH32_USB-FS-Device_Driver\inc;..\..\..\..\Libraries\w55mh32Lib\inc;..\..\..\..\Libraries\CORE;..\..\..\..\Libraries\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group User
    ./: main.c w55mh32_it.c
  group Startup
    ./: startup_w55mh32.s
  group CMSIS
    ../../../../Libraries/CORE/: core_cm3.c
    ./: system_w55mh32.c
  group StdPeriph_Driver
    ../../../../Libraries/w55mh32Lib/src/: w55mh32_rcc.c w55mh32_gpio.c misc.c w55mh32_exti.c w55mh32_pwr.c w55mh32_flash.c w55mh32_dma.c
  group USB_CORE
    ../USB/W55MH32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group USB_CONFIG
    ../USB/CONFIG/: dfu_mal.c flash_if.c opt_if.c hw_config.c usb_desc.c usb_istr.c usb_prop.c usb_pwr.c
software components: CMSIS:CORE 5.5.0
