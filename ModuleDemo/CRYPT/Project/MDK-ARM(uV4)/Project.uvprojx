# Keil uVision project Project.uvprojx, settings and files
target Flash (5060960::V5.06 update 7 (build 960)::.\ARM Compiler 5.06 update 7)
  device: W55MH32L WIZnet
  pack: WIZnet.W55MH32_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=Bin\@L.bin !L
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER,USE_FULL_ASSERT
  c include: ..\..\User;..\..\User\cryptlibTest;..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\Libraries\W55MH32Lib\inc;..\..\..\..\Libraries\W55MH32Lib\inc\cryptlib;..\..\..\..\Libraries\CORE;..\..\..\..\Libraries\W55MH32Lib\lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  link misc: --callgraph
  group User
    ../../User/: main.c w55mh32_it.c
  group MDK-ARM
    ./: startup_w55mh32.s
  group WIZSCPU_Driver
    ../../../../Libraries/W55MH32Lib/src/: misc.c w55mh32_gpio.c w55mh32_rcc.c w55mh32_tim.c w55mh32_trng.c w55mh32_usart.c
  group CMSIS
    ./: system_w55mh32.c
  group CRYPT_SELF_TEST
    ../../User/cryptlibTest/: debug.c wiz_bignum_tool.c aes_self_test.c des_self_test.c sha_self_test.c sm1_self_test.c sm4_self_test.c sm7_self_test.c sm3_self_test.c
  group CRYPT_LIB
    ../../../../Libraries/W55MH32Lib/lib/: wiz_crypt.lib
target RAM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER,USE_FULL_ASSERT,STM32F10X_HD
  c include: ..\..\..\..\Libraries\mhF103Lib\inc;..\..\..\..\Libraries\mhF103Lib\inc\cryptlib;..\..\..\..\Libraries\CORE;..\..\..\..\Libraries\STM32F10x_FWLib\inc;..\..\User\cryptlibTest;..\..\User
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --callgraph
software components: CMSIS:CORE 6.1.0
