# Keil uVision project Project.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: W55MH32L WIZnet
  pack: W55MH32.W55MH32_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=Bin\@L.bin !L
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,W55MH32_XL
  c include: ..\USER;..\..\..\..\..\Libraries\W55MH32Lib\inc;..\..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\..\Libraries\CORE;..\..\..\..\..\Libraries\CMSIS\Lib\ARM;..\..\..\..\..\Libraries\ioLibrary\Ethernet;..\..\..\..\..\Libraries\ioLibrary\Internet\DHCP;..\..\..\..\..\Libraries\W55MH32Lib\lib;..\USER\wiz_interface;..\USER\tim;..\USER\uart;..\USER\delay;..\USER\rcc;..\USER\udp_config;..\USER\flash;..\USER\ota;..\USER\config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group CORE
    ../../../../../Libraries/CORE/: core_cm3.c startup_w55mh32.s
  group FWLib
    ../../../../../Libraries/W55MH32Lib/src/: misc.c w55mh32_rcc.c w55mh32_gpio.c w55mh32_usart.c w55mh32_spi.c w55mh32_bkp.c w55mh32_tim.c w55mh32_exti.c w55mh32_flash.c
  group Lib
    ../../../../../Libraries/W55MH32Lib/lib/: w55mh32_toe.lib w55mh32.lib
  group USER
    ../USER/: main.c w55mh32_it.c
    ../../../../../Libraries/W55MH32Lib/src/: system_w55mh32.c
    ../USER/wiz_interface/: wiz_interface.c
    ../USER/tim/: bsp_tim.c
    ../USER/uart/: bsp_uart.c
    ../USER/delay/: delay.c
    ../USER/rcc/: bsp_rcc.c
    ../USER/udp_config/: udp_config.c
    ../USER/flash/: flash.c
    ../USER/ota/: fw_update.c
    ../USER/config/: config.c
  group Ethernet
    ../../../../../Libraries/ioLibrary/Ethernet/: socket.c wizchip_conf.c
  group Internet
    ../../../../../Libraries/ioLibrary/Internet/DHCP/: dhcp.c
