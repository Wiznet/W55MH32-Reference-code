# Keil uVision project Project.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: W55MH32L WIZnet
  pack: W55MH32.W55MH32_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  AfterMake: fromelf.exe #L --vhx --8x1 --output main.hex;fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\USER;..\..\..\..\Libraries\W55MH32Lib\inc;..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\Libraries\CORE;..\..\..\..\Libraries\CMSIS\Lib\ARM;..\..\..\..\Libraries\W55MH32Lib\lib;..\..\..\..\Libraries\ioLibrary\Ethernet;..\..\..\..\Libraries\ioLibrary\Internet\DHCP;..\..\..\..\Libraries\ioLibrary\Internet\DNS;..\..\..\..\Libraries\ioLibrary\Internet\MQTT;..\..\..\..\Libraries\ioLibrary\Internet\MQTT\MQTTPacket\src;..\USER\wiz_interface;..\USER\tim;..\USER\uart;..\USER\CJSON;..\USER\delay;..\USER\DNS;..\USER\MQTT;..\USER\rcc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group CORE
    ../../../../Libraries/CORE/: core_cm3.c startup_w55mh32.s
  group FWLib
    ../../../../Libraries/W55MH32Lib/src/: misc.c w55mh32_rcc.c w55mh32_gpio.c w55mh32_usart.c w55mh32_spi.c w55mh32_bkp.c w55mh32_tim.c w55mh32_exti.c
  group Lib
    ../../../../Libraries/W55MH32Lib/lib/: w55mh32_toe.lib w55mh32.lib
  group USER
    ../USER/: main.c w55mh32_it.c
    ../../../../Libraries/W55MH32Lib/src/: system_w55mh32.c
    ../USER/wiz_interface/: wiz_interface.c
    ../USER/tim/: bsp_tim.c
    ../USER/uart/: bsp_uart.c
    ../USER/delay/: delay.c
    ../USER/CJSON/: cJSON.c
    ../USER/DNS/: do_dns.c
    ../USER/MQTT/: do_mqtt.c
    ../USER/rcc/: bsp_rcc.c
  group Ethernet
    ../../../../Libraries/ioLibrary/Ethernet/: socket.c wizchip_conf.c
  group Internet
    ../../../../Libraries/ioLibrary/Internet/DHCP/: dhcp.c
    ../../../../Libraries/ioLibrary/Internet/DNS/: dns.c
    ../../../../Libraries/ioLibrary/Internet/MQTT/: mqtt_interface.c MQTTClient.c
    ../../../../Libraries/ioLibrary/Internet/MQTT/MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
