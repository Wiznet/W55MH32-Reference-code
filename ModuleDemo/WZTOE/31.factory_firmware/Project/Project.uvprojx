# Keil uVision project Project.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: W55MH32L WIZnet
  pack: W55MH32.W55MH32_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=Bin\@L.bin !L
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,W55MH32_XL
  c misc: --no-multibyte-chars
  c include: ..\USER;..\..\..\..\Libraries\W55MH32Lib\inc;..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\Libraries\CORE;..\..\..\..\Libraries\CMSIS\Lib\ARM;..\..\..\..\Libraries\ioLibrary\Ethernet;..\..\..\..\Libraries\ioLibrary\Internet\DHCP;..\USER\wiz_interface;..\USER\tim;..\USER\uart;..\USER\delay;..\USER\httpServer;..\USER\eeprom;..\USER\user_web;..\USER\gpio;..\USER\aht20;..\USER\USB\CONFIG;..\USER\USB\W55MH32_USB-FS-Device_Driver\inc;..\..\..\..\Libraries\W55MH32Lib\lib;..\USER\rcc;..\USER\USB;..\USER\sdio\fatfs;..\USER\sdio\sdio;..\USER\sdio
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group CORE
    ../../../../Libraries/CORE/: core_cm3.c
    ../USER/: startup_w55mh32.s
  group FWLib
    ../../../../Libraries/W55MH32Lib/src/: misc.c w55mh32_rcc.c w55mh32_gpio.c w55mh32_usart.c w55mh32_spi.c w55mh32_bkp.c w55mh32_tim.c w55mh32_exti.c w55mh32_dma.c w55mh32_sdio.c w55mh32_wwdg.c w55mh32_iwdg.c w55mh32_pwr.c
  group TOELib
    ../../../../Libraries/W55MH32Lib/lib/: w55mh32_toe.lib w55mh32.lib
  group USER
    ../USER/: main.c system_w55mh32.c w55mh32_it.c
    ../USER/wiz_interface/: wiz_interface.c
    ../USER/tim/: bsp_tim.c
    ../USER/uart/: bsp_uart.c
    ../USER/delay/: delay.c
    ../USER/eeprom/: eeprom.c
    ../USER/user_web/: userHandler.c
    ../USER/gpio/: user_gpio.c
    ../USER/aht20/: aht20.c
    ../USER/rcc/: user_rcc.c
    ../USER/USB/: user_usb.c
    ../USER/sdio/: user_sdio.c
  group Ethernet
    ../../../../Libraries/ioLibrary/Ethernet/: socket.c wizchip_conf.c
  group Internet
    ../../../../Libraries/ioLibrary/Internet/DHCP/: dhcp.c
    ../USER/httpServer/: httpParser.c httpServer.c httpUtil.c
  group USB
    ../USER/USB/CONFIG/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
    ../USER/USB/W55MH32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group SDIO
    ../USER/sdio/fatfs/: diskio.c ff.c
    ../USER/sdio/fatfs/option/: cc936.c
    ../USER/sdio/sdio/: bsp_sdio_sdcard.c sdio_test.c
