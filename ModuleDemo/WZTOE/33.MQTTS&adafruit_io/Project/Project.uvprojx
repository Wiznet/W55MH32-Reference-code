# Keil uVision project Project.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: W55MH32L WIZnet
  pack: WIZnet.W55MH32_DFP.1.0.1
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  AfterMake: fromelf.exe #L --vhx --8x1 --output main.hex;fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER MBEDTLS_CONFIG_FILE=<SSLConfig.h>
  c include: ..\USER;..\..\..\..\Libraries\W55MH32Lib\inc;..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\Libraries\CORE;..\..\..\..\Libraries\CMSIS\Lib\ARM;..\..\..\..\Libraries\ioLibrary\Ethernet;..\..\..\..\Libraries\ioLibrary\Internet\DHCP;..\..\..\..\Libraries\ioLibrary\Internet\DNS;..\..\..\..\Libraries\ioLibrary\Internet\MQTT;..\..\..\..\Libraries\ioLibrary\Internet\MQTT\MQTTPacket\src;..\..\..\..\Libraries\W55MH32Lib\lib;..\..\..\..\Libraries\W55MH32Lib\inc\cryptlib;..\USER\wiz_interface;..\USER\tim;..\USER\uart;..\USER\delay;..\USER\rcc;..\USER\gpio;..\USER\aht20;..\USER\mbedTLS;..\mbedtls\include;..\USER\CJSON;..\USER\DNS;..\USER\MQTT
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group CORE
    ../../../../Libraries/CORE/: core_cm3.c
    ../USER/: startup_w55mh32.s
  group FWLib
    ../../../../Libraries/W55MH32Lib/src/: misc.c w55mh32_rcc.c w55mh32_gpio.c w55mh32_usart.c w55mh32_spi.c w55mh32_bkp.c w55mh32_tim.c w55mh32_exti.c w55mh32_trng.c
  group Lib
    ../../../../Libraries/W55MH32Lib/lib/: w55mh32_toe.lib w55mh32.lib
  group USER
    ../USER/: main.c system_w55mh32.c w55mh32_it.c
    ../USER/wiz_interface/: wiz_interface.c
    ../USER/tim/: bsp_tim.c
    ../USER/uart/: bsp_uart.c
    ../USER/delay/: delay.c
    ../USER/rcc/: bsp_rcc.c
    ../USER/aht20/: aht20.c
    ../USER/gpio/: user_gpio.c
    ../USER/CJSON/: cJSON.c
    ../USER/MQTT/: do_mqtt.c
    ../USER/DNS/: do_dns.c
  group Ethernet
    ../../../../Libraries/ioLibrary/Ethernet/: socket.c wizchip_conf.c
  group Internet
    ../../../../Libraries/ioLibrary/Internet/DHCP/: dhcp.c
    ../../../../Libraries/ioLibrary/Internet/DNS/: dns.c
    ../../../../Libraries/ioLibrary/Internet/MQTT/: MQTTClient.c mqtt_interface.c
    ../../../../Libraries/ioLibrary/Internet/MQTT/MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group mbedTLS
    ../mbedtls/library/: aes.c aesce.c aesni.c aria.c asn1parse.c asn1write.c base64.c bignum.c bignum_core.c bignum_mod.c bignum_mod_raw.c block_cipher.c camellia.c ccm.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c constant_time.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c ecp_curves_new.c entropy.c entropy_poll.c error.c gcm.c hkdf.c hmac_drbg.c lmots.c lms.c md.c md5.c memory_buffer_alloc.c mps_reader.c mps_trace.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_ecc.c pk_wrap.c pkcs5.c pkcs7.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c psa_crypto.c psa_crypto_aead.c psa_crypto_cipher.c psa_crypto_client.c psa_crypto_driver_wrappers_no_static.c psa_crypto_ecp.c psa_crypto_ffdh.c psa_crypto_hash.c psa_crypto_mac.c psa_crypto_pake.c psa_crypto_rsa.c psa_crypto_se.c psa_crypto_slot_management.c psa_crypto_storage.c psa_its_file.c psa_util.c ripemd160.c rsa.c rsa_alt_helpers.c sha1.c sha3.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_client.c ssl_cookie.c ssl_debug_helpers_generated.c ssl_msg.c ssl_ticket.c ssl_tls.c ssl_tls12_client.c ssl_tls12_server.c ssl_tls13_client.c ssl_tls13_generic.c ssl_tls13_keys.c ssl_tls13_server.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write.c x509write_crt.c x509write_csr.c
  group CRYPT_LIB
    ../../../../Libraries/W55MH32Lib/lib/: wiz_crypt.lib
  group mbedTLS_Interface
    ../USER/mbedTLS/: util.c SSLInterface.c SSL_Random.c aes_alt.c des_alt.c mbedtls_sha1_alt.c mbedtls_sha256_alt.c
