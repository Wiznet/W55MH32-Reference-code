# Keil uVision project TEST.uvprojx, settings and files
target TEST (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: W55MH32L WIZnet
  pack: WIZnet.W55MH32_DFP.1.0.1
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TEST +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=Bin\@L.bin !L
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,RTE_USING_FINSH
  c include: ..\..\..\..\..\Libraries\w55mh32Lib\inc;..\..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\..\Libraries\CORE;..\..\..\..\..\Libraries\CMSIS\Lib\ARM;..\..\..\..\..\Libraries\w55mh32Lib\lib;..\rt-thread\include\libc;..\rt-thread\include;..\rt-thread\bsp;..\rt-thread\components\finsh;.\inc;..\..\..\..\..\Libraries\ioLibrary\Ethernet;..\..\..\..\..\Libraries\ioLibrary\Internet\DHCP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group USER
    ../rt-thread/bsp/: board.c
    ./src/: bsp_rcc.c bsp_tim.c bsp_uart.c loopback.c main.c system_w55mh32.c w55mh32_it.c wiz_interface.c
  group CORE
    ../../../../../Libraries/CORE/: core_cm3.c
    ./: startup_w55mh32.s
  group FWLib
    ../../../../../Libraries/w55mh32Lib/src/: misc.c w55mh32_rcc.c w55mh32_gpio.c w55mh32_usart.c
    ../../../../../Libraries/W55MH32Lib/src/: w55mh32_spi.c w55mh32_tim.c
  group RTT/SOURCE
    ../rt-thread/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
  group RTT/PORT
    ../rt-thread/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
  group Ethnet
    ../../../../../Libraries/ioLibrary/Ethernet/: socket.c wizchip_conf.c
  group Internet
    ../../../../../Libraries/ioLibrary/Internet/DHCP/: dhcp.c
  group Lib
    ../../../../../Libraries/W55MH32Lib/lib/: w55mh32.lib w55mh32_toe.lib
