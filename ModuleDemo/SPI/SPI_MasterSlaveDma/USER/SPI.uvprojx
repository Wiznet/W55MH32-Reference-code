# Keil uVision project SPI.uvprojx, settings and files
target SPI (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: W55MH32L WIZnet
  pack: W55MH32.W55MH32_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SPI +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=Bin\@L.bin !L
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,W55MH32_XL
  c include: ..\SYSTEM\delay;..\USER;..\..\..\..\Libraries\w55mh32Lib\inc;..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\Libraries\CORE;..\..\..\..\Libraries\CMSIS\Lib\ARM;..\..\..\..\Libraries\W55MH32Lib\lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group USER
    ./: main.c w55mh32_it.c
    ../../../../Libraries/w55mh32Lib/src/: system_w55mh32.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
  group CORE
    ../../../../Libraries/CORE/: core_cm3.c startup_w55mh32.s
  group FWLib
    ../../../../Libraries/w55mh32Lib/src/: misc.c w55mh32_rcc.c w55mh32_gpio.c w55mh32_usart.c w55mh32_spi.c w55mh32_dma.c
  group Lib
    ../../../../Libraries/W55MH32Lib/lib/: w55mh32.lib
